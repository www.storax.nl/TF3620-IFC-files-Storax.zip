Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 68448640-749f-4dbe-9c0b-51f32768b685, NumberOfSaves: 1]
File name: Project Number
Time: 2026-01-30T16:55:36+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family1:Standard, Family1:Standard:209533
In: Level 1
Type - Material: Aluminum - Flat
Type - Other - Category: Generic Models; Family Name: Family1
Type - Model Properties - Artikelnummer: 10362000210; Author: NW; Comments: rev 01- anti-groove; Creation Date: 26/03/2025; Designer: NW; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TF-3620 Glas Profil L=2500mm, Aluminium unbehandelt; OnLevel description DK: TF-3620 glasprofil L=2500mm, aluminium rå overfl.; OnLevel description EN: TF-3620 glass profile L=2500mm, aluminum mill finish; OnLevel description ES: TF-3620 perfil de vidrio L=2500mm, aluminio sin tratar; OnLevel description FR: TF-3620 profil verre L=2500mm, aluminium non traitée; OnLevel description GB: TF-3620 glass profile L=2500mm, aluminum mill finish; OnLevel description NL: TF-3620 glas profiel L=2500mm, aluminium onbehandeld; OnLevel description NO: TF-3620 glassprofil L=2500mm, aluminium rå overflate; OnLevel description RU: TF-3620 профиль стекла L=2500mm, oтделка алюм. mель.; OnLevel description SE: TF-3620 glasprofil L=2500mm, aluminium obehand. utför.; OnLevel description US: TF-3620 glass profile L=2500mm, aluminum mill finish; Part Number: 10362000210; Revision Number: 02; Revisionsnummer: 02; Title: 10362000210; Toleranzangabe: DIN EN 12020 - 2
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family1; Family and Type: Family1: Standard; Type: Standard; Type Id: 209518
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 1.89776 m2; Volume: 0.00785754 m3
Phasing - Phase Created: New Construction
