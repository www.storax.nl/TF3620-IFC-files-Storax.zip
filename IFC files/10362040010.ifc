Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: a39dd251-70bf-4077-bde6-919e072d5c5e, NumberOfSaves: 1]
File name: Project Number
Time: 2026-01-30T17:18:37+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family9:Standard, Family9:Standard:209528
In: Level 1
Type - Material: Aluminum - Flat(1)
Type - Other - Category: Generic Models; Family Name: Family9
Type - Model Properties - Artikelnummer: 10362040010; Author: NW; Creation Date: 04/09/2025; Designer: NW; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TURBOFLEX TL-3620 Endkappe Links Aluminium unbehandelt; OnLevel description DK: TURBOFLEX TL-3620 endekappe Venstre aluminium rå overfl.; OnLevel description EN: TURBOFLEX TL-3620 endcap Left aluminum mill finish; OnLevel description ES: TURBOFLEX TL-3620 tapón de acabado Izq. aluminio sin tratar; OnLevel description FR: TURBOFLEX TL-3620 bouchon Gauche aluminium non traitée; OnLevel description GB: TURBOFLEX TL-3620 endcap Left aluminum mill finish; OnLevel description NL: TURBOFLEX TL-3620 eindkap Links aluminium onbehandeld; OnLevel description NO: TURBOFLEX TL-3620 endekap Venstre aluminium rå overflate; OnLevel description RU: TURBOFLEX TL-3620 плоская крышка Оставил oтделка алюм. mель.; OnLevel description SE: TURBOFLEX TL-3620 ändlock Vänster aluminium obehand. utför.; OnLevel description US: TURBOFLEX TL-3620 endcap Left aluminum mill finish; Part Number: 10362040010; Title: 10362040010; toleranzangabe: ISO 2768 - m
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family9; Family and Type: Family9: Standard; Type: Standard; Type Id: 209513
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0107243 m2; Volume: 0.0000196 m3
Phasing - Phase Created: New Construction
